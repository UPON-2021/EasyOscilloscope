# Keil uVision project Oscilloscope.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 简易示波器 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\HARDWARE\ADC;..\HARDWARE\DMA;..\HARDWARE\LCD;..\HARDWARE\LED;..\STM32F10x_FWLib\inc;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\KEY;..\HARDWARE\STM32F10x_DSP_Lib\inc;..\HARDWARE\TIMER;..\HARDWARE\BEEP;..\HARDWARE\DAC;..\HARDWARE\EXTI;..\HARDWARE\IC
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c ui.c
  group HARDWARE
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/DMA/: dma.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/EXTI/: exti.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/STM32F10x_DSP_Lib/src/: cr4_fft_1024_stm32.s
    ../HARDWARE/STM32F10x_DSP_Lib/inc/: table_fft.h stm32_dsp.h
    ../HARDWARE/IC/: IC.c IC.h
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_dac.c stm32f10x_exti.c
